PACKAGECONFIG_remove_mingw32 = "python"
