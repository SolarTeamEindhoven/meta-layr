#do_compile_append() {
#	oe_runmake docs || die "make failed"
#}
