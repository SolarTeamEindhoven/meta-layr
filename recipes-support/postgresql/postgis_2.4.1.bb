include postgis.inc

SRC_URI[md5sum] = "d5f9444fbbddb6a33fabc106d67703b9"
SRC_URI[sha256sum] = "a47d88b3085bd8ad21ad1231e1e7a33a81035785bea70c6712377553b371744e"
