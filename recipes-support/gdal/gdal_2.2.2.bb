include gdal.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=65b35c879d7e99557086d68a48c385ea"

SRC_URI[md5sum] = "b81b7b31d8984435db1b1637cee80e30"
SRC_URI[sha256sum] = "14c1f78a60f429ad51c08d75cbf49771f1e6b20e7385c6e8379b40e8dfa39544"
