PACKAGECONFIG += "mapboxgl"
