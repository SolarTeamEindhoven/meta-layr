RDEPENDS_${PN}_remove = "packagegroup-b2qt-embedded-addons"
