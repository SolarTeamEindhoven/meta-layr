FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRCREV = "118d2cda4d38848406b1f21fce82b31175350ce7"
SRC_URI += "file://0001-Use-DBUS-property-changed-signal.patch"
