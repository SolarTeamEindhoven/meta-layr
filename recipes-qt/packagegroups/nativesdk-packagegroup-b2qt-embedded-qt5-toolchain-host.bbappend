RDEPENDS_${PN} += "\
	nativesdk-qtwayland-tools \
	"
