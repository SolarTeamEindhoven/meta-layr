RDEPENDS_${PN}_remove = "weston weston-examples"
